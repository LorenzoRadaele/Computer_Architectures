# Keil uVision project Lab09.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lab09
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group led
    ./13_LPC1768_led_button/led/: led.h lib_led.c
    ./: funct_led.c
  group main
    ./13_LPC1768_led_button/: sample.c
  group button
    ./13_LPC1768_led_button/button/: button.h IRQ_button.c lib_button.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0
