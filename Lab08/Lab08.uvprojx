# Keil uVision project Lab08.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: LPC1786 NXP
  pack: Keil.LPC1700_DFP.2.7.0
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lab08
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
